options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: halow_rx
    output_language: python
  states: {}

blocks:
- name: activity_threshold
  id: variable
  parameters:
    comment: power level greater than this value satisfies second condition
    value: '-80'
  states: {}
- name: correlation_threshold
  id: variable
  parameters:
    comment: less that this value satisfies first condition
    value: '0.4'
  states: {}
- name: driver
  id: variable
  parameters:
    value: '"airspy"'
  states: {}
- name: filter_cutoff
  id: variable
  parameters:
    value: (samp_rate / 2) - (samp_rate /10)
  states: {}
- name: filter_transition
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '21'
    value: '10'
  states: {}
- name: guard_interval_size
  id: variable
  parameters:
    value: '8'
  states: {}
- name: halow_channel_json_filename
  id: variable
  parameters:
    comment: location of JSON file for channels to scan
    value: '''/home/dragon/Documents/gr-halow/flowgraphs/1mhz_halow_channels.json'''
  states: {}
- name: input_samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: loiter_time
  id: variable
  parameters:
    comment: in seconds, how long to wait on each channel
    value: '0.5'
  states: {}
- name: lpf_taps
  id: variable
  parameters:
    value: firdes.low_pass(1, input_samp_rate, filter_cutoff, filter_transition)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sdr_center_freq
  id: variable
  parameters:
    value: '918000000'
  states: {}
- name: start_time
  id: variable
  parameters:
    comment: in seconds, 1mhz_mcs0 capture
    value: '7.607'
  states: {state: disabled}
- name: stop_time
  id: variable
  parameters:
    comment: in seconds, 1mhz_mcs0 capture
    value: '7.674'
  states: {state: disabled}
- name: training_field_size
  id: variable
  parameters:
    comment: in samples, length of STF + LTF
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '24'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: guard_interval_size
    type: complex
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: training_field_size
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/dragon/Documents/gr-halow/captures/1mhz-mcs0.sigmf-data
    length: int((stop_time - start_time) * input_samp_rate)
    offset: int(start_time * input_samp_rate)
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: window_size  + guard_interval_size
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: input_samp_rate
    type: complex
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import json
      import os

      class blk(gr.sync_block):  


          def __init__(self, upper_detection_threshold=0.2, correlation_threshold=0.2, halow_channel_json_filename=""): 
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='HaLow Usage Detector',  
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.upper_detection_threshold = upper_detection_threshold
              self.correlation_threshold = correlation_threshold
              self.halow_channel_json_filename = halow_channel_json_filename
              self.all_halow_channels = {}
              if(os.path.isfile(halow_channel_json_filename)):
                  json_file = open(self.halow_channel_json_filename)
                  self.all_halow_channels = json.load(json_file)
                  json_file.close()
              self.port_freq_in = "freq_in"
              self.message_port_register_in(pmt.intern(self.port_freq_in))
              self.set_msg_handler(pmt.intern(self.port_freq_in), self.handle_freq_in)
              self.port_tune_in = "tune_in"
              self.message_port_register_in(pmt.intern(self.port_tune_in))
              self.set_msg_handler(pmt.intern(self.port_tune_in), self.handle_tune_in)
              self.tune_frequency = 0
              self.offset_frequency = 0

          def handle_tune_in(self, msg):
              key = pmt.intern("freq")
              value = pmt.dict_ref(msg, key, pmt.PMT_NIL) 
              if(value is not pmt.PMT_NIL):
                  self.tune_frequency = pmt.to_double(value)
          
          def handle_freq_in(self, msg):
              key = pmt.intern("freq")
              value = pmt.dict_ref(msg, key, pmt.PMT_NIL) 
              if(value is not pmt.PMT_NIL):
                  self.offset_frequency = pmt.to_double(value)

          def channel_lookup(self):
              channel_frequency = self.tune_frequency + self.offset_frequency
              #print(f"{self.tune_frequency} {self.offset_frequency}")
              for channel, value in self.all_halow_channels.items():
                  if(value["freq"] == channel_frequency):
                      return (channel, value)
              return (-1, -1)

          def work(self, input_items, output_items):
              # this block does not operate on samples
              output_items[0][:] = input_items[0]

              # find any identified wifi frames and print out the current channel
              
              
              
              tags = self.get_tags_in_window(0, 0, len(input_items[0]))
              channel = self.channel_lookup()
              for tag in tags:
                  key = pmt.to_python(tag.key)
                  value = pmt.to_python(tag.value)
                  #print(f"{value} {self.upper_detection_threshold} {channel[0]}")
                  if(np.abs(value) < self.correlation_threshold and channel[0] != -1):
                      tag_index = tag.offset - self.nitems_read(0)
                      average = 0
                      for i in range(tag_index, tag_index + 10):
                          if(i < len(input_items[0])):
                              average += np.real(input_items[0][i])**2 + np.imag(input_items[0][i])**2
                      average = 10 * np.log10(average/10)
                      #print(average)
                      if(average > self.upper_detection_threshold):
                          channel_freq = channel[1]["freq"]/1e6
                          channel_bw   = channel[1]["bw"]/1e6
                          print(f"HaLow activity - channel {channel[0]:>4s}, freq {channel_freq:>6.1f} MHz, bw {channel_bw:>4.1f} MHz, power avg: {average:>6.2f} dB")

              return len(output_items[0])
    comment: |-
      detections whose correlation is less than the correlation threshold
      and whose power average exceeds the power threshold will be
      perceived as HaLow activity
    correlation_threshold: correlation_threshold
    halow_channel_json_filename: halow_channel_json_filename
    upper_detection_threshold: activity_threshold
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\nimport json\nimport os\n\nclass blk(gr.sync_block): \n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, loiter_time=2, sdr_center_freq=902e6, sdr_samp_rate=10e6, samp_rate=1e6, debug=False, halow_channel_json_filename=\"\"):\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='HaLow Scan Controller', \n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        self.halow_channel_json_filename = halow_channel_json_filename\n        self.debug = debug\n        self.all_halow_channels = {}\n        if(os.path.isfile(halow_channel_json_filename)):\n            json_file = open(self.halow_channel_json_filename)\n            self.all_halow_channels = json.load(json_file)\n            json_file.close()\n        else:\n            print(\"incorrect file path!\")\n        self.sdr_center_freq = sdr_center_freq\n        self.samp_rate = samp_rate\n        self.sdr_samp_rate = sdr_samp_rate\n        self.port_freq_control = \"freq_control\"\n        self.port_tuning_control = \"tuning_control\"\n        self.message_port_register_out(pmt.intern(self.port_freq_control))\n        self.message_port_register_out(pmt.intern(self.port_tuning_control))\n        self.available_halow_channels = []\n        self.channel_index = 0\n        self.loiter_samples = int(loiter_time * samp_rate) # how many samples to read before switching channels\n        self.sample_count = 0\n        self.freq_message = None\n        self.tune_message = None\n\n        # first time setup operations\n        self.find_available_channels()\n        freq_offset = 0 # initial offset of 0 unless there are available channels\n        if(len(self.available_halow_channels) > 0):\n            freq_offset = self.available_halow_channels[self.channel_index][1][\"freq\"] - self.sdr_center_freq\n        self.set_freq_message(freq_offset) # initial offset of 0\n        self.set_tune_message(self.sdr_center_freq)\n        print(f\"{len(self.available_halow_channels)} available halow channels in the current range\")\n\n    def find_available_channels(self):\n        self.available_halow_channels = []\n        for channel, value in self.all_halow_channels.items():\n            channel_lowerbound = value[\"freq\"] - value[\"bw\"]/2\n            channel_upperbound = value[\"freq\"] + value[\"bw\"]/2\n            radio_lowerbound = self.sdr_center_freq - self.sdr_samp_rate / 2\n            radio_upperbound = self.sdr_center_freq + self.sdr_samp_rate / 2\n            if(channel_lowerbound >= radio_lowerbound and channel_upperbound <= radio_upperbound):\n                self.available_halow_channels.append((channel, value))\n\n    def find_next_tuning_freq(self):\n        radio_lowerbound = self.sdr_center_freq - self.sdr_samp_rate / 2\n        radio_upperbound = self.sdr_center_freq + self.sdr_samp_rate / 2\n        search_lowerbound = radio_upperbound - 4e6 # 4e6 because it is the maximum width of a HaLow channel that we care about\n        first_channel_miss = None # we will set the radio lowerbound so that it captures the first missed channel\n        count = 0 # ensures we don't have endless while loop\n        if(search_lowerbound < radio_lowerbound):\n            search_lowerbound = radio_lowerbound\n\n        # find first channel miss\n        while(first_channel_miss is None):\n            for channel, value in self.all_halow_channels.items():\n                # detect miss\n                right_of_search_lowerbound = value[\"freq\"] >= search_lowerbound\n                outside_current_range      = radio_upperbound < (value[\"freq\"] + value[\"bw\"]/2)\n                sdr_can_capture            = value[\"bw\"] <= self.sdr_samp_rate\n                if(right_of_search_lowerbound and outside_current_range and sdr_can_capture):\n                    # new lowest miss\n                    if(first_channel_miss is None or value[\"freq\"] < first_channel_miss[1][\"freq\"]):\n                        first_channel_miss = (channel, value)\n            # wraparound condition\n            if(first_channel_miss is None and count < 1):\n                search_lowerbound = 902e6 # lowest edge of ISM band\n                radio_upperbound = 901e6 # 1MHz lower than lowest edge of ISM band\n                count = count + 1\n            elif(first_channel_miss is None and count >= 1):\n                return self.sdr_center_freq\n        \n        new_tuning_freq = (self.sdr_samp_rate / 2) + (first_channel_miss[1][\"freq\"] - first_channel_miss[1][\"bw\"] / 2)\n        return new_tuning_freq\n\n\n    def set_freq_message(self, freq_offset):\n        self.freq_message = pmt.make_dict()\n        self.freq_message = pmt.dict_add(self.freq_message, pmt.intern(\"freq\"), pmt.from_double(freq_offset))\n\n    def set_tune_message(self, tuning_freq):\n        self.sdr_center_freq = tuning_freq\n        self.tune_message = pmt.make_dict()\n        self.tune_message = pmt.dict_add(self.tune_message, pmt.intern(\"freq\"), pmt.from_double(tuning_freq))\n        self.find_available_channels()\n\n    def work(self, input_items, output_items):\n        # pass all samples through; this block doesn't change samples, it just detects them for timing\n        output_items[0][:] = input_items[0]\n\n        # increment sample count so we know how long we've stared at a channel before switching to the next\n        self.sample_count = self.sample_count + len(input_items[0])\n        if(self.sample_count > self.loiter_samples):\n            self.sample_count = 0\n            self.channel_index = self.channel_index + 1\n            # check for rollover condition\n            if(self.channel_index >= len(self.available_halow_channels)):\n                self.channel_index = 0\n                next_tuning_freq = self.find_next_tuning_freq()\n                if(self.debug):\n                    print(f\"SDR frequency is {next_tuning_freq/1e6:.2f} MHz\")\n                self.set_tune_message(next_tuning_freq)\n            if(len(self.available_halow_channels) > 0):\n                if(self.debug):\n                    print(f\"current channel is {self.available_halow_channels[self.channel_index][0]} freq {self.available_halow_channels[self.channel_index][1]['freq']/1e6:.2f} MHz, bw {self.available_halow_channels[self.channel_index][1]['bw']/1e6:.2f} MHz\")\n                self.set_freq_message(self.available_halow_channels[self.channel_index][1][\"freq\"] - self.sdr_center_freq)\n\n        # control FIR filter and tuner\n        self.message_port_pub(pmt.intern(self.port_freq_control), self.freq_message)\n        self.message_port_pub(pmt.intern(self.port_tuning_control), self.tune_message)\n        \n        # GRC expects this as a return value\n        return len(output_items[0])\n\n"
    debug: 'True'
    halow_channel_json_filename: halow_channel_json_filename
    loiter_time: loiter_time
    samp_rate: samp_rate
    sdr_center_freq: sdr_center_freq
    sdr_samp_rate: input_samp_rate
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: sdr_center_freq
    decim: int(input_samp_rate/samp_rate)
    samp_rate: input_samp_rate
    taps: lpf_taps
    type: ccc
  states: {}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: training_field_size
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.7'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    entags: 'False'
    label1: ''
    name: '"autocorrelation"'
    size: (int((stop_time - start_time) * samp_rate) - 8) * 5
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"post sync long"'
    size: '16500'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"post sync short"'
    size: '16500'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"input signal"'
    size: int((stop_time - start_time) * samp_rate)
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    center_freq0: sdr_center_freq
    dc_removal0: 'False'
    driver: driver
    gain0: gain
    samp_rate: input_samp_rate
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tuning_control
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: freq_control
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tuning_control
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: tuning_control
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: freq_control
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: freq_control
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_delay_0_0_0, '0', ieee802_11_sync_long_0, '1']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '2']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_xx_1, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_1, '0', ieee802_11_sync_short_0, '1']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_tag_gate_0, '0', epy_block_1, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_1_0, '0']
- [epy_block_1, '0', blocks_complex_to_mag_squared_0, '0']
- [epy_block_1, '0', blocks_delay_0_0, '0']
- [epy_block_1, '0', blocks_multiply_xx_0, '0']
- [epy_block_1, '0', qtgui_time_sink_x_2, '0']
- [epy_block_1, freq_control, virtual_sink_0_0, '0']
- [epy_block_1, tuning_control, virtual_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_tag_gate_0, '0']
- [ieee802_11_sync_long_0, '0', epy_block_0, '0']
- [ieee802_11_sync_short_0, '0', blocks_delay_0_0_0, '0']
- [ieee802_11_sync_short_0, '0', ieee802_11_sync_long_0, '0']
- [ieee802_11_sync_short_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [soapy_custom_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_0, '0', soapy_custom_source_0, cmd]
- [virtual_source_0_0, '0', epy_block_0, tune_in]
- [virtual_source_0_0_0, '0', epy_block_0, freq_in]
- [virtual_source_0_0_0_0, '0', freq_xlating_fir_filter_xxx_0, freq]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
