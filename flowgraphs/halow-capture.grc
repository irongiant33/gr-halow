options:
  parameters:
    generate_options: qt_gui
    id: halowcapture
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: int(915.5e6)
  states: {}
- name: filter_cutoff
  id: variable
  parameters:
    value: 600e3
  states: {state: disabled}
- name: filter_transition
  id: variable
  parameters:
    value: 10e3
  states: {state: disabled}
- name: offset_freq
  id: variable
  parameters:
    value: 2.5e6
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: int(10e6)
  states: {}
- name: blocks_sigmf_sink_minimal_0
  id: blocks_sigmf_sink_minimal
  parameters:
    author: Sam Miller
    center_freq: np.nan
    comment: |-
      don't forget to change your filename after running to
      avoid overwriting your captures
    description: capture channel 164, 4 MHz channel centered at 918 MHz between two Alfa HaLow-U nodes, no encryption with MCS1 no rate control
    filename: /home/dragon/Documents/gr-halow/captures/filenamehere
    sample_rate: samp_rate
    type: complex float (fc32_le)
  states: {state: disabled}
- name: blocks_sigmf_source_minimal_0
  id: blocks_sigmf_source_minimal
  parameters:
    file: /home/dragon/Documents/gr-halow/captures/4mhz-mcs1-chan164.sigmf-data
    repeat: 'False'
    type: complex float (fc32_le)
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    agc0: 'False'
    balance0: '0'
    center_freq0: center_freq
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    devname: airspy
    overall_gain0: '3'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [blocks_sigmf_source_minimal_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [soapy_source_0, '0', blocks_sigmf_sink_minimal_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
